# Keil uVision project SIHAN_LPC824_LOCK.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: LPC824M201JHI33 NXP
  pack: Keil.LPC800_DFP.1.1.0
  cpu: IROM(0x00000000,0x8000) IRAM(0x10000000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: SIHAN_LPC824_LOCK +hex
  c flags: Optim=1 wLevel=2
  c define: CHIP_LPC82X
  c include: .\CM0+;.\LPC8xx;.\include;C:\Keil_v5\ARM\Pack\ARM\CMSIS\4.2.0\CMSIS\Include;.\SRC\FM175xx;.\SRC\IOS14443;.\SRC\LPCD\inc
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group LPC8xx
    ./LPC8xx/: LPC8xx_Gpio.c LPC8xx_Spi.c LPC8xx_Uart.c system_LPC8xx.c uart.c
    ./LPC8xx/startup/: startup_lpc82x.s
  group user_code
    ./user_code/: main.c test.c
    ./SRC/Utility/: Utility.c
  group FM175xx
    ./SRC/FM175xx/: fm175xx.c
  group ISO14443A
    ./SRC/IOS14443/: mifare_card.c NTAG.c type_a.c
  group ISO14443B
    ./SRC/IOS14443/: type_b.c
